# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-F103RB (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NUCLEO-F103RB
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Services
    ../Src/: Voilier.c
  group MyDrivers
    ../Src/: Allure.c AntiCharvirement.c Batterie.c Gouvernail.c Heure.c Transmission.c Voile.c MyTimer.c
  group Drivers/STM32f1xx_LL_Driver
    ../LLDrivers/src/: stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Example/MDK-ARM
    ./: startup_stm32f103xb.s
target Simulateur (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: NUCLEO-F103RB
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ..\Inc;..\LLDrivers\inc;..\Services;..\MyDrivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
